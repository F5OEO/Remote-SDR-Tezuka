options:
  parameters:
    author: F5OEO
    copyright: GNU General Public Licence v3.0
    description: RX for Tezuka Firmware
    generate_options: no_gui
    id: RX_Pluto_Tezuka
    output_language: python
    run_options: run
    title: TezukaRx
  states: {}

blocks:
- name: Ffine
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Fsdr
  id: variable
  parameters:
    value: '432000000'
  states: {}
- name: G1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: G2
  id: variable
  parameters:
    value: '-20'
  states: {}
- name: G3
  id: variable
  parameters:
    value: '20'
  states: {}
- name: LSB_USB
  id: variable
  parameters:
    value: min(1,Modulation)
  states: {}
- name: Largeur_filtre_AM
  id: variable
  parameters:
    value: '7500'
  states: {}
- name: Largeur_filtre_NBFM
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: Largeur_filtre_SSB
  id: variable
  parameters:
    value: '3800'
  states: {}
- name: Largeur_filtre_WBFM
  id: variable
  parameters:
    value: '150000'
  states: {}
- name: ModulSelect
  id: variable
  parameters:
    value: max(0,Modulation -1)
  states: {}
- name: Modulation
  id: variable
  parameters:
    value: '0'
  states: {}
- name: Squelch
  id: variable
  parameters:
    value: '-80'
  states: {}
- name: decim_LP
  id: variable
  parameters:
    value: '27'
  states: {}
- name: maia_url
  id: variable
  parameters:
    value: '"http://127.0.0.1:8000"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: SampRate
  states: {}
- name: xlate_filter_taps_AM
  id: variable
  parameters:
    value: firdes.low_pass(1, baseband, Largeur_filtre_AM/2, 1500)
  states: {}
- name: xlate_filter_taps_NBFM
  id: variable
  parameters:
    value: firdes.low_pass(1,baseband, Largeur_filtre_NBFM/2, 2000)
  states: {}
- name: xlate_filter_taps_SSB
  id: variable
  parameters:
    value: firdes.low_pass(1, baseband, Largeur_filtre_SSB/2, 760)
  states: {}
- name: xlate_filter_taps_WBFM
  id: variable
  parameters:
    value: firdes.low_pass(1, baseband, Largeur_filtre_WBFM/2, 25000)
  states: {}
- name: SampRate
  id: parameter
  parameters:
    type: eng_float
    value: '1200000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    max_gain: '100'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '20000'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '10000'
    max_dev: 5e3
    quad_rate: '40000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Largeur_filtre_SSB/2+100
    offset: '0'
    phase: '0'
    samp_rate: '10000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: analog_simple_squelch_cc_0_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: Squelch
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(baseband/10000)
    quad_rate: baseband
  states: {}
- name: baseband
  id: parameter
  parameters:
    label: baseband
    type: eng_float
    value: '200000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '16000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-2*LSB_USB
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '4'
    output_index: ModulSelect
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: ModulSelect
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 1/2048
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: 1/2048
  states: {}
- name: device
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import subprocess\nimport numpy as np\nfrom gnuradio import gr\nimport sys, threading, time\n\n# Adjust your path as needed\nsys.path.append(\"/home/analog/maia\")\nfrom maialib4 import MaiaPerParamClient, MaiaAPIError\n\nclass blk(gr.basic_block):\n    \"\"\"Maia Source control block (no stream I/O)\"\"\"\n\n    def __init__(self,\n                 frequency=1000e6,\n                 frequency_nco=0,\n                 samplerate=1.2e6,\n                 rxgain=50,\n                 baseband=200000,                                     \n                 url=\"http://127.0.0.1:8000\"):\n        gr.basic_block.__init__(self,\n            name='Maia Source',\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.url = url\n        self.frequency = frequency\n        self.frequency_nco = frequency_nco\n        self.samplerate = samplerate\n        self.baseband = baseband\n        self.decim = int(samplerate/self.baseband)\n        self.client = None\n        self._running = False\n        self.rxgain = rxgain\n\n\n        print(\"Init: Frequency setting\", self.frequency, flush=True)\n        self.start()\n\n    # --- Runtime setters (callbacks GRC will call) ---\n    def set_frequency(self, frequency):\n        self.frequency = frequency\n        if self.client:\n            try:\n                self.client.set_rx_lo_frequency(frequency)\n            except MaiaAPIError as e:\n                print(\"Failed to set frequency:\", e, flush=True)\n        print(\"Frequency updated:\", frequency, flush=True)\n\n    def set_frequency_nco(self, frequency_nco):\n        self.frequency_nco = frequency_nco\n        if self.client:\n            try:\n                self.client.set_ddc_frequency(frequency_nco)\n            except MaiaAPIError as e:\n                print(\"Failed to set NCO:\", e, flush=True)\n        print(\"Frequency NCO updated:\", frequency_nco, flush=True)\n\n    def set_samplerate(self, samplerate):\n        self.samplerate = samplerate\n        self.client.set_sampling_frequency(self.samplerate)\n        self.client.set_rx_rf_bandwidth(self.samplerate)\n        print(\"Samplerate updated:\", samplerate, flush=True)\n    \n    def set_rxgain(self, rxgain):\n           self.rxgain = rxgain\n           self.client.set_rx_gain_mode(\"Manual\")\n           self.client.set_rx_gain(self.rxgain)\n           print(\"Gain updated:\", samplerate, flush=True) \n\n    def set_decim(self, decim):\n        self.decim = decim\n        print(\"Decimation updated:\", decim, flush=True)\n\n    # --- Lifecycle hooks ---\n    def start(self):\n        print (\"Starting\", self.url)\n        \n        self.client = MaiaPerParamClient(self.url)\n        try:\n            self.set_samplerate(self.samplerate)\n            self.client.set_rx_lo_frequency(self.frequency)\n            self.client.put_ddc_design_params(\n                self.frequency_nco,\n                self.decim,\n                0.05, 0.01, 50, True\n            )\n            self.client.set_spectrometer_sampling_frequency(10)\n        except MaiaAPIError as e:\n            print(\"Failed to configure Maia client:\", e, flush=True)\n\n        subprocess.run([\"busybox\", \"devmem\", \"0x790200BC\", \"32\", \"0x1\"])\n        self._running = True\n        self.thread = threading.Thread(target=self.run, daemon=True)\n        self.thread.start()\n        return super().start()\n\n    def run(self):\n        while self._running:\n            time.sleep(1)\n\n    def stop(self):\n        self._running = False\n        if hasattr(self, \"thread\") and self.thread.is_alive():\n            self.thread.join()\n        return super().stop()\n\n"
    alias: MaiaSource
    baseband: '200000'
    frequency: Fsdr
    frequency_nco: Ffine
    rxgain: G2
    samplerate: samp_rate
    url: maia_url
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 0-Largeur_filtre_SSB/2+LSB_USB*Largeur_filtre_SSB-100+LSB_USB*200
    decim: int(baseband/10000)
    samp_rate: baseband
    taps: xlate_filter_taps_SSB
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: int(baseband/(40000))
    samp_rate: baseband
    taps: xlate_filter_taps_NBFM
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: int(baseband/10000)
    samp_rate: baseband
    taps: xlate_filter_taps_AM
    type: ccc
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '[''voltage0'',''voltage1'']'
    decimation: '1'
    device: '''cf-ad9361-lpc'''
    device_phy: '''ad9361-phy'''
    params: '[]'
    uri: 'local:'
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '19001'
    type: short
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '9003'
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_float_0, '0']
- [analog_agc_xx_0, '0', analog_simple_squelch_cc_0_0, '0']
- [analog_nbfm_rx_0, '0', blocks_selector_1, '2']
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [analog_simple_squelch_cc_0_0, '0', blocks_complex_to_mag_0, '0']
- [analog_simple_squelch_cc_0_1, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', blocks_selector_1, '3']
- [blocks_add_xx_0, '0', blocks_selector_1, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_multiply_xx_0_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_selector_1, '1']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '0']
- [blocks_float_to_short_0, '0', network_tcp_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_selector_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_selector_0, '1', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_selector_0, '2', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_selector_0, '3', analog_simple_squelch_cc_0_1, '0']
- [blocks_selector_1, '0', blocks_float_to_short_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '1']
- [blocks_short_to_float_1, '0', blocks_float_to_complex_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', analog_agc_xx_0, '0']
- [iio_device_source_0, '0', blocks_short_to_float_1, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
