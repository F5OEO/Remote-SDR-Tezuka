options:
  parameters:
    author: F5OEO
    copyright: GNU General Public Licence v3.0
    description: TX SSB NBFM tezuka
    generate_options: no_gui
    id: TX_Pluto_tezuka
    output_language: python
    run_options: run
    title: SSB NBFM Transmitter
  states: {}

blocks:
- name: Fsdr
  id: variable
  parameters:
    value: '432100000'
  states: {}
- name: G1
  id: variable
  parameters:
    value: '70'
  states: {}
- name: G2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: LNUC
  id: variable
  parameters:
    value: '0'
  states: {}
- name: maia_url
  id: variable
  parameters:
    value: '"http://127.0.0.1:8000"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: SampRate
  states: {}
- name: SampRate
  id: parameter
  parameters:
    type: eng_float
    value: '6400000'
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: baseband
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: int(baseband*5)
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1300+LNUC*1500
    low_cutoff_freq: '-1300+LNUC*1500'
    samp_rate: baseband
    type: fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: baseband
    type: fir_filter_fff
    width: '1200'
    win: window.WIN_HAMMING
  states: {}
- name: baseband
  id: parameter
  parameters:
    label: baseband
    type: eng_float
    value: '10000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: LNUC
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: abs(LNUC)
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: abs(LNUC)
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: hardwaregain
    target: str(-float(89-G1))
  states: {}
- name: device
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import subprocess\nimport numpy as np\nfrom gnuradio import gr\nimport sys, threading, time\n\n# Adjust your path as needed\nsys.path.append(\"/home/analog/maia\")\nfrom maialib4 import MaiaPerParamClient, MaiaAPIError\n\nclass blk(gr.basic_block):\n    \"\"\"Maia Source control block (no stream I/O)\"\"\"\n\n    def __init__(self,\n                 frequency=1000e6,\n                 \n                 samplerate=1.2e6,\n                 txgain=50,\n                 baseband=200000,                                     \n                 url=\"http://127.0.0.1:8000\"):\n        gr.basic_block.__init__(self,\n            name='MaiaTx',\n            in_sig=[],\n            out_sig=[]\n        )\n\n        self.url = url\n        self.frequency = frequency\n\n        self.samplerate = samplerate\n        self.baseband = baseband\n        self.decim = int(samplerate/self.baseband)\n        self.client = None\n        self._running = False\n        self.txgain = txgain\n\n\n        print(\"Init: Frequency setting\", self.frequency, flush=True)\n        self.start()\n\n    # --- Runtime setters (callbacks GRC will call) ---\n    def set_frequency(self, frequency):\n        self.frequency = frequency\n        if self.client:\n            try:\n                self.client.set_tx_lo_frequency(frequency)\n            except MaiaAPIError as e:\n                print(\"Failed to set frequency:\", e, flush=True)\n        print(\"Frequency updated:\", frequency, flush=True)\n\n    def set_frequency_nco(self, frequency_nco):\n        self.frequency_nco = frequency_nco\n        if self.client:\n            try:\n                self.client.set_ddc_frequency(frequency_nco)\n            except MaiaAPIError as e:\n                print(\"Failed to set NCO:\", e, flush=True)\n        print(\"Frequency NCO updated:\", frequency_nco, flush=True)\n\n    def set_samplerate(self, samplerate):\n        self.samplerate = samplerate\n        self.client.set_sampling_frequency(self.samplerate)\n        self.client.set_tx_rf_bandwidth(self.samplerate)\n        print(\"Samplerate updated:\", samplerate, flush=True)\n    \n    def set_txgain(self, txgain):\n           self.txgain = txgain\n\n           self.client.set_tx_gain(self.txgain)\n           print(\"TXGain updated:\", self.txgain, flush=True) \n\n    \n    # --- Lifecycle hooks ---\n    def start(self):\n        print (\"Starting\", self.url)\n        \n        \n        # Force Interpolator x8\n        subprocess.run([\"busybox\", \"devmem\", \"0x790240BC\", \"32\", \"0x1\"])\n        self._running = True\n        self.thread = threading.Thread(target=self.run, daemon=True)\n        self.thread.start()\n        return super().start()\n\n    def run(self):\n        while self._running:\n            time.sleep(1)\n\n    def stop(self):\n        self._running = False\n        if hasattr(self, \"thread\") and self.thread.is_alive():\n            self.thread.join()\n        return super().stop()\n\n"
    alias: MaiaTX
    baseband: baseband
    frequency: Fsdr
    samplerate: samp_rate
    txgain: G1
    url: maia_url
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    maxoutbuf: '10'
    minoutbuf: '10'
    num_taps: '64'
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: voltage0
    device: ad9361-phy
    output: 'True'
    uri: 'local:'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: int(samp_rate)
    buffer_size: '32000'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: Fsdr
    samplerate: int(samp_rate)
    type: fc32
    uri: 'local:'
  states: {}
- name: interpol
  id: parameter
  parameters:
    type: intx
    value: '32'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '128'
    port: '19005'
    src_zeros: 'False'
    type: short
  states: {}
- name: note_0
  id: note
  parameters:
    note: CW
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: SSB
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/(baseband*interpol))
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/(baseband*5*interpol))
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/(baseband*interpol))
    taps: ''
    type: ccc
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '19004'
  states: {}

connections:
- [analog_const_source_x_1, '0', blocks_float_to_complex_0_0, '1']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_1_0, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [band_pass_filter_0_0, '0', analog_nbfm_tx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0_0, '0', rational_resampler_xxx_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_selector_0, '0', band_pass_filter_0_0, '0']
- [blocks_selector_0, '1', hilbert_fc_0, '0']
- [blocks_selector_0, '2', blocks_float_to_complex_0_0, '0']
- [blocks_selector_1, '0', iio_pluto_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_selector_0, '0']
- [blocks_var_to_msg_0, msgout, blocks_message_debug_0, print]
- [blocks_var_to_msg_0, msgout, iio_attr_sink_0, attr]
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [network_udp_source_0, '0', blocks_short_to_float_0, '0']
- [rational_resampler_xxx_1, '0', blocks_selector_1, '1']
- [rational_resampler_xxx_1_0, '0', blocks_selector_1, '0']
- [rational_resampler_xxx_1_1, '0', blocks_selector_1, '2']

metadata:
  file_format: 1
