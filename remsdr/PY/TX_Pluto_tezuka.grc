options:
  parameters:
    author: F5OEO
    copyright: GNU General Public Licence v3.0
    description: TX SSB NBFM tezuka
    generate_options: no_gui
    id: TX_Pluto_tezuka
    output_language: python
    run_options: run
    title: SSB NBFM Transmitter
  states: {}

blocks:
- name: Fsdr
  id: variable
  parameters:
    value: '432100000'
  states: {}
- name: G1
  id: variable
  parameters:
    value: '70'
  states: {}
- name: G2
  id: variable
  parameters:
    value: '0'
  states: {}
- name: LNUC
  id: variable
  parameters:
    value: '0'
  states: {}
- name: TX_ON
  id: variable
  parameters:
    value: '0'
  states: {}
- name: maia_url
  id: variable
  parameters:
    value: '"http://127.0.0.1:8000"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: SampRate
  states: {}
- name: SampRate
  id: parameter
  parameters:
    type: eng_float
    value: '6400000'
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: baseband
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: int(baseband*5)
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1300+LNUC*1500
    low_cutoff_freq: '-1300+LNUC*1500'
    samp_rate: baseband
    type: fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: baseband
    type: fir_filter_fff
    width: '1200'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1300+LNUC*1500
    low_cutoff_freq: '-1300+LNUC*1500'
    samp_rate: baseband
    type: fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1300+LNUC*1500
    low_cutoff_freq: '-1300+LNUC*1500'
    samp_rate: baseband
    type: fir_filter_ccc
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: baseband
  id: parameter
  parameters:
    label: baseband
    type: eng_float
    value: '10000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: LNUC
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '3'
    output_index: abs(LNUC)
    type: float
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: abs(LNUC)
    num_inputs: '3'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32767'
  states: {}
- name: cessb_clipper_cc_0
  id: cessb_clipper_cc
  parameters:
    clip: '0.353553390593'
  states: {}
- name: cessb_stretcher_cc_0
  id: cessb_stretcher_cc
  parameters: {}
  states: {}
- name: device
  id: parameter
  parameters:
    type: str
    value: ''
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import subprocess\nimport numpy as np\nfrom gnuradio import gr\nimport sys, threading, time\nimport adi\n\n# Adjust your path as needed\nsys.path.append(\"/home/analog/maia\")\nfrom maialib4 import MaiaPerParamClient, MaiaAPIError\n\nclass blk(gr.basic_block):\n    \"\"\"Maia Destination control block (no stream I/O)\"\"\"\n\n    def __init__(self,\n                 frequency=1000e6,\n                 txgain=50,\n                 txon=0,\n                 rfbandwidth=200e3,\n                 ):\n        gr.basic_block.__init__(self,\n            name='MaiaTx',\n            in_sig=[],\n            out_sig=[]\n        )\n\n        \n        self.frequency = frequency\n\n        self.client = None\n        self._running = False\n        self.txgain = txgain\n        self.txon = txon\n        self.rfbandwidth=rfbandwidth\n        print(\"Init: Frequency setting\", self.frequency, flush=True)\n        self.sdr = None\n        self.init()\n        self.start()\n\n    # --- Runtime setters (callbacks GRC will call) ---\n    def set_frequency(self, frequency):\n        self.frequency = frequency\n        self.sdr.tx_lo = self.frequency \n        print(\"Frequency updated:\", frequency, flush=True)\n\n   \n    def set_txgain(self, txgain):\n           self.txgain = txgain\n           hardwaregain=str(-float(89-self.txgain)) \n           tx_chan = self.phy.find_channel(\"voltage0\", True) \n           tx_chan.attrs[\"hardwaregain\"].value=hardwaregain\n           print(\"TXGain updated:\", hardwaregain, flush=True) \n    \n    def set_txon(self, txon):\n           self.txon = txon\n           tx_chan = self.phy.find_channel(\"altvoltage1\", True) \n           try:\n               if txon is True:\n                    tx_chan.attrs[\"powerdown\"].value=\"0\"\n               else:\n                    tx_chan.attrs[\"powerdown\"].value=\"1\"\n           except Exception as e:\n             print(\"Warning: TXON:\", e, flush=True)\n     \n           print(\"Txon updated:\", self.txon, flush=True) \n\n    def set_rfbandwidth(self, txon):\n           \n           self.sdr.tx_rf_bandwidth = self.rfbandwidth\n\n    # --- Lifecycle hooks ---\n    def init(self):\n        \n        print(\"Starting TX:\") \n        try:\n            self.sdr=adi.ad9361(uri=\"local:\")\n            self.ctx= self.sdr.ctx\n            self.phy=self.ctx.find_device(\"ad9361-phy\")\n            tx_chan = self.phy.find_channel(\"altvoltage1\", True) \n            \n            # Force Interpolator x32\n            subprocess.run([\"busybox\", \"devmem\", \"0x790240BC\", \"32\", \"0x1\"])\n        except Exception as e:\n            print(\"Warning: SDR init failed:\", e, flush=True)\n    \n    def start(self):\n        self._running = True\n        self.thread = threading.Thread(target=self.run, daemon=True)\n        self.thread.start()\n        return super().start()\n\n    def run(self):\n        while self._running:\n            time.sleep(1)\n            self.set_txon(self.txon)\n            self.set_txgain(self.txgain)\n            subprocess.run([\"busybox\", \"devmem\", \"0x790240BC\", \"32\", \"0x1\"])\n            #interp=subprocess.run([\"busybox\", \"devmem\", \"0x790240BC\"])\n            #print(\"Interp \",interp)        \n\n    def stop(self):\n        self._running = False\n        if hasattr(self, \"thread\") and self.thread.is_alive():\n            self.thread.join()\n        return super().stop()\n\n    \n"
    alias: MaiaTX
    frequency: Fsdr
    rfbandwidth: 200e3
    txgain: G1
    txon: TX_ON
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    maxoutbuf: '10'
    minoutbuf: '10'
    num_taps: '64'
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Off'''
    frequency: Fsdr
    rf_port_select: '''A'''
    samplerate: int(samp_rate)
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: 'local:'
  states: {}
- name: interpol
  id: parameter
  parameters:
    type: intx
    value: '32'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '128'
    port: '19005'
    src_zeros: 'False'
    type: short
  states: {}
- name: note_0
  id: note
  parameters:
    note: CW
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: SSB
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/(baseband*interpol))
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/(baseband*5*interpol))
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/(baseband*interpol))
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: clipper-filter
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: clipper-filter
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '19004'
  states: {}

connections:
- [analog_const_source_x_1, '0', blocks_float_to_complex_0_0, '1']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_1_0, '0']
- [band_pass_filter_0, '0', cessb_clipper_cc_0, '0']
- [band_pass_filter_0_0, '0', analog_nbfm_tx_0, '0']
- [band_pass_filter_0_1, '0', cessb_stretcher_cc_0, '0']
- [band_pass_filter_0_1_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0_0, '0', rational_resampler_xxx_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '1']
- [blocks_selector_0, '0', band_pass_filter_0_0, '0']
- [blocks_selector_0, '1', hilbert_fc_0, '0']
- [blocks_selector_0, '2', blocks_float_to_complex_0_0, '0']
- [blocks_selector_1, '0', iio_fmcomms2_sink_0, '0']
- [blocks_short_to_float_0, '0', blocks_selector_0, '0']
- [cessb_clipper_cc_0, '0', virtual_sink_0, '0']
- [cessb_stretcher_cc_0, '0', band_pass_filter_0_1_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_0, '0']
- [network_udp_source_0, '0', blocks_short_to_float_0, '0']
- [rational_resampler_xxx_1, '0', blocks_selector_1, '1']
- [rational_resampler_xxx_1_0, '0', blocks_selector_1, '0']
- [rational_resampler_xxx_1_1, '0', blocks_selector_1, '2']
- [virtual_source_0, '0', band_pass_filter_0_1, '0']

metadata:
  file_format: 1
